## tests/app/testcase.yaml
```yaml
common:
  # integration_platforms:
  #   - native_sim
  tags:
    - embsys330_fp_tests
tests:
  sample.testing.embsys330_fp_tests: {}
```
